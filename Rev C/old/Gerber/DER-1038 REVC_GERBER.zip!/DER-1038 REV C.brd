# Allegro board DER-1038 REV C.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
N13971397 on TOP: 76.34,13.91 75.31,14.94 75.31,24.74 75.56,24.99 95.66,24.99 95.91,24.74 95.91,17.78 92.04,13.91
N13971397 on BOTTOM: 103.35,25.04 103.76,24.64 103.76,12.37 103.15,11.76 95.25,11.76 95.15,11.86 95.15,13.18 94.63,13.7 89.7,13.7 88.01,12.01 83.87,12.01 83.13,11.28 83.13,10.85 83.16,10.82 83.16,9.3 82.83,8.97 79.73,8.97 79.48,9.22 79.48,9.58 78.49,10.57 78.13,10.57 77.47,11.23 77.47,14.07 75.39,16.15 75.39,24.84 75.59,25.04

Small or netless copper shapes (teardrops, artwork): 13 on BOTTOM

## Text on the board
Ref Des/Silkscreen Top: DER-1038 | 2420 | REV C | S/N | L | N | 4.167A | 24V | +Vo | -Vo
DIMENSION: 14.  FAB HOUSE LOGO,DATE CODE TO BE IN SILK SCREEN ONLY.DO NOT USE COPPER. | 13.  MATERIAL FR4 COPPER 2oz THICKNESS 0.040" | NOTES: PLEASE DELETE THESE PINS
PAGE_OUTLINE: FIGURE | FINISHED_SIZE | 18.0 | 30.0 | 35.0 | 40.0 | 50.0 | 51.0 | 60.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE_DRILL | +0.0/-0.0 | +3.0/-3.0 | PLATED | QTY | 995 | 9 | 2 | 1 | 18 | 6 | 13 | 3
